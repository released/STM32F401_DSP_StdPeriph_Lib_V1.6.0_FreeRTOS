# IAR project Project.ewp, settings and files
configuration STM32F401xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\inc; ..\..\..\Utilities\FreeRTOS\Source\include; ..\..\..\Utilities\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Libraries\CMSIS\RTOS\Template; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Lib\ARM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Libraries\CMSIS\Lib\ARM\arm_cortexM4lf_math.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ARM Math
    ../../../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_const_structs.c
    ../../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s
  group FreeRTOS
    ../../../Utilities/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_portable
    ../../../Utilities/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../src/: Custom_ADC.c debug.c Hw_config.c macro.c main.c stm32f4xx_it.c system_stm32f4xx.c
